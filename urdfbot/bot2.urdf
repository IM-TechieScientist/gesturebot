Commit message: second bot

File: urdfbot/bot2.urdf (robot description, URDF)
Before this commit: robot bot_2, 16 links, 15 joints
Joints:
- joint wheel6_wheelhand: origin xyz=-0.03 -0.05 -0.08 rpy=0 0 0 -> xyz=-0.03 0.05 -0.08 rpy=0 0 0
